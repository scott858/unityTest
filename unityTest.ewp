# IAR project unityTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZN64xxx2 NXP KEAZN64xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: UNITY_OUTPUT_FLUSH=1; UNITY_OMIT_OUTPUT_FLUSH_HEADER_DECLARATION=1
  ICCARM.CCIncludePath2: src; C:\Users\sleewin\repos\code\Unity\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    src/: ProductionCode.c ProductionCode.h unity.h unity_internals.h
    ../Unity/src/: unity.c
  group test
    test/: TestProductionCode.c
  group test/test_runners
    test/test_runners/: TestProductionCode_Runner.c
